// ====================================================================
// lunar_cal.h — 精确农历/干支/黄历宜忌（离线计算，无需网络/API）
// 农历数据表 1900~2100（编码: bit0-3=闰月月份[0无闰] bit4-15=1-12月大小[1=30天] bit16=闰月大小[1=30]）
// 日干支基准: 1900-01-31 = 甲辰(60甲子序40)
// 黄历宜忌: 传统"建除十二神"规则（建星=(日支-月支+12)%12）
// 由 gen_lunar.py 从 zhdate 生成，勿手改
// ====================================================================
#ifndef LUNAR_CAL_H
#define LUNAR_CAL_H

#include <stdint.h>
#include <string.h>

static const uint32_t LUNAR_CODE[201] = {
    19416, 19168, 42352, 21717, 53856, 55632, 91476, 22176, 39632, 21970,
    19168, 42422, 42192, 53840, 119381, 46400, 54944, 44450, 38320, 84343,
    18800, 42160, 46261, 27216, 27968, 109396, 11104, 38256, 21234, 18800,
    25958, 54432, 59984, 92821, 23248, 11104, 100067, 37600, 116951, 51536,
    54432, 120998, 46416, 22176, 107956, 9680, 37584, 53938, 43344, 46423,
    27808, 46416, 86869, 19872, 42416, 83315, 21168, 43432, 59728, 27296,
    44710, 43856, 19296, 43748, 42352, 21088, 62051, 55632, 23383, 22176,
    38608, 19925, 19152, 42192, 54484, 53840, 54616, 46400, 46752, 103846,
    38320, 18864, 43380, 42160, 45690, 27216, 27968, 44870, 43872, 38256,
    19189, 18800, 25776, 29859, 59984, 27480, 23232, 43872, 38613, 37600,
    51552, 55636, 54432, 55888, 30034, 22176, 43959, 9680, 37584, 51893,
    43344, 46240, 47780, 44368, 21977, 19360, 42416, 86390, 21168, 43312,
    31060, 27296, 44368, 23378, 19296, 42726, 42208, 53856, 60005, 54576,
    23200, 30371, 38608, 19195, 19152, 42192, 118966, 53840, 54560, 56645,
    46496, 22224, 21938, 18864, 42359, 42160, 43600, 111189, 27936, 44448,
    84835, 37744, 18936, 18800, 25776, 92326, 59984, 27296, 108228, 43744,
    37600, 53987, 51552, 54615, 54432, 55888, 23893, 22176, 42704, 21972,
    21200, 43448, 43344, 46240, 46758, 44368, 21920, 43940, 42416, 21168,
    45683, 26928, 29495, 27296, 44368, 84821, 19296, 42352, 21732, 53600,
    59752, 54560, 55968, 92838, 22224, 19168, 43476, 41680, 53584, 62034,
    54560,
};

// 公历转儒略日（内部）
static long ljulianDay(int y, int m, int d) {
    if (m <= 2) { y--; m += 12; }
    return 365L * y + y / 4 - y / 100 + y / 400 + (153L * m - 457) / 5 + d - 306;
}

// 某农历年某月天数（1-12 普通月，返回 29/30）
static int lunarMonthDays(int ly, int m) {
    uint32_t c = LUNAR_CODE[ly - 1900];
    return ((c >> (16 - m)) & 1) ? 30 : 29;
}
// 某农历年闰月月份（0=无闰）
static int lunarLeapMonth(int ly) { return LUNAR_CODE[ly - 1900] & 0xF; }
// 某农历年闰月天数
static int lunarLeapDays(int ly) { return ((LUNAR_CODE[ly - 1900] >> 16) & 1) ? 30 : 29; }
// 某农历年总天数
static int lunarYearDays(int ly) {
    int s = 0;
    for (int m = 1; m <= 12; m++) s += lunarMonthDays(ly, m);
    if (lunarLeapMonth(ly)) s += lunarLeapDays(ly);
    return s;
}

// 公历转农历（ly=农历年 lm=农历月 ld=农历日 leap=是否闰月）
static void solarToLunar(int y, int mo, int d, int& ly, int& lm, int& ld, bool& leap) {
    long off = ljulianDay(y, mo, d) - ljulianDay(1900, 1, 31);
    ly = 1900;
    while (off >= lunarYearDays(ly)) { off -= lunarYearDays(ly); ly++; }
    int lmLeap = lunarLeapMonth(ly);
    leap = false;
    for (int m = 1; m <= 12; m++) {
        int md = lunarMonthDays(ly, m);
        if (off < md) { lm = m; ld = (int)off + 1; return; }
        off -= md;
        if (m == lmLeap) {
            int ld2 = lunarLeapDays(ly);
            if (off < ld2) { lm = m; ld = (int)off + 1; leap = true; return; }
            off -= ld2;
        }
    }
    lm = 12; ld = (int)off + 1;
}

// 日干支 60 甲子序号（0-59），基准 1900-01-31=甲辰(40)
static int dayGanzhiSeq(int y, int mo, int d) {
    long diff = ljulianDay(y, mo, d) - ljulianDay(1900, 1, 31);
    return (int)((40 + diff % 60 + 60) % 60);
}

static const char* const LUNAR_GAN[10] = {"甲","乙","丙","丁","戊","己","庚","辛","壬","癸"};
static const char* const LUNAR_ZHI[12] = {"子","丑","寅","卯","辰","巳","午","未","申","酉","戌","亥"};
static const char* const LUNAR_SHENG[12] = {"鼠","牛","虎","兔","龙","蛇","马","羊","猴","鸡","狗","猪"};
static const char* const LUNAR_MONTH_CN[13] = {"","正","二","三","四","五","六","七","八","九","十","冬","腊"};
static const char* const LUNAR_DAY_CN[31] = {"初一","初二","初三","初四","初五","初六","初七","初八","初九","初十",
    "十一","十二","十三","十四","十五","十六","十七","十八","十九","二十",
    "廿一","廿二","廿三","廿四","廿五","廿六","廿七","廿八","廿九","三十"};

// 建除十二神（建=0 除=1 满=2 平=3 定=4 执=5 破=6 危=7 成=8 收=9 开=10 闭=11）
static const char* const JIANCHU_NAME[12] = {"建","除","满","平","定","执","破","危","成","收","开","闭"};
static const char* const JIANCHU_YI[12] = {
    "出行 上任 会友", "除旧 沐浴 扫舍", "祭祀 祈福 求医",
    "修造 平路 习艺", "安床 交易 嫁娶", "捕捉 入宅 祈福",
    "破屋 求医 坏垣", "安床 祈福 交易", "嫁娶 开市 入学",
    "纳财 收藏 修仓", "开业 出行 动土", "安葬 补垣 塞穴",
};
static const char* const JIANCHU_JI[12] = {
    "动土 开仓 嫁娶", "嫁娶 出行 置产", "开业 动土 安葬",
    "开渠 放水 动土", "诉讼 出行 搬家", "开市 搬迁 出行",
    "嫁娶 开市 出行", "登高 行船 开市", "诉讼 安葬 求医",
    "出行 安葬 开仓", "安葬 行丧 嫁娶", "开市 出行 嫁娶",
};

// 计算建除十二神索引（0-11）：农历月支(正月=寅) + 日支
static int calcJianChu(int lunarMonth, int dayZhi) {
    int mzhi = (lunarMonth + 1) % 12;   // 正月=寅(2)
    return ((dayZhi - mzhi) + 12) % 12;
}

#endif // LUNAR_CAL_H
